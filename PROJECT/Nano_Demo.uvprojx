# Keil uVision project Nano_Demo.uvprojx, settings and files
target NanoCh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Nano_Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\CMSIS;..\USER;..\SYSTEM\inc;..\HARDWARE\inc;..\NET\device\inc;..\NET\MQTT;..\NET\onenet\inc;..\MALLOC;..\FATFS;..\FATFS\src;..\FATFS\exfuns;..\FATFS\src\option;..\TEXT;..\USB\STM32_USB-FS-Device_Driver\inc;..\USB\CONFIG;..\API\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group API
    ../API/src/: file_api.c oled_api.c sys_api.c
    ../USER/: test.c
  group HARDWARE
    ../HARDWARE/src/: beep.c key.c led.c rtc.c smg.c oled.c spi.c mmc_sd.c flash.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c myunicode.c
    ../FATFS/exfuns/: exfuns.c fattester.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group USB_COR
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group SYSTEM
    ../SYSTEM/src/: delay.c sys.c usart.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group CORE
    ../STM32F10x_FWLib/CMSIS/: core_cm3.c system_stm32f10x.c
    ../STM32F10x_FWLib/CMSIS/startup/: startup_stm32f10x_md.s
  group DOC
    ../DOC/: README.TXT
